SUMMARY = "Python 2 and 3 compatibility library"
LICENSE = "LGPLv2"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/LGPL-2.0;md5=9427b8ccf5cf3df47c29110424c9641a"

SRC_URI[md5sum] = "bedcdb3a0ed85986d40044c87f23477c"
SRC_URI[sha256sum] = "81e883e0b9517d624e8b0499eb267b82a815c0b7146d5269f364988ae031279d"

inherit pypi setuptools3 native
