SUMMARY = "Python 2 and 3 compatibility library"
LICENSE = "APACHE"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

SRC_URI[md5sum] = "411d5f8b92a25610bc56c32e74c4463a"
SRC_URI[sha256sum] = "28a1af453ed004e1a17eea9cd97b9bdd1d9fead6e770a6b1f0bd46541042fed0"

inherit pypi setuptools3 native
