SUMMARY = "Python 2 and 3 compatibility library"
LICENSE = ""
LIC_FILES_CHKSUM = "file://LICENSE;md5=6016fe224b0bae2284037e384b0e9d4d"

SRC_URI[md5sum] = "576e1f063b8e74dbfeda02d978564987"
SRC_URI[sha256sum] = "9071aacbd97a9a915096c1aaf0dc684ac2672904cd876db5904085d6dac9810e"

inherit pypi setuptools3 native
