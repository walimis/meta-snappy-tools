SUMMARY = "Python 2 and 3 compatibility library"
LICENSE = "APACHE"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

SRC_URI[md5sum] = "f7863ab5144a3ace64a4c851ec290907"
SRC_URI[sha256sum] = "cc4e9c0ef810d6dfd165ca680330b65a4cf8a3f08f5f08ecd50a0253a08e541f"

inherit pypi setuptools3 native
