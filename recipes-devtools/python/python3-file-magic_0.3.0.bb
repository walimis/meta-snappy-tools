SUMMARY = "Python 2 and 3 compatibility library"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD;md5=3775480a712fc46a69647678acb234cb"

SRC_URI[md5sum] = "101a1e165ec43ad5233efb97ea1fc590"
SRC_URI[sha256sum] = "c8654256900eb696b52f7a5d4b3c672e737541ba4ff466d2fcc2b9fb1844c7f5"

inherit pypi setuptools3 native
