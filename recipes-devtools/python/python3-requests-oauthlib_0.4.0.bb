SUMMARY = "Python 2 and 3 compatibility library"
LICENSE = "APACHE"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

SRC_URI[md5sum] = "2649560205a02473998e0e7dd881ee5a"
SRC_URI[sha256sum] = "c9f7ba22900114118747901e3b7835f4b67abbec537cb9d87f7bb5d31ff78d48"

inherit pypi setuptools3 native
