SUMMARY = "Python 2 and 3 compatibility library"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI[md5sum] = "22fa7b1041f458c582396206cfee4e7e"
SRC_URI[sha256sum] = "9a3de55308e41abdbc05f6e205c20ed36f928860cce490fa9835231ab9cb3c32"

inherit pypi setuptools3 native
