SUMMARY = "Python 2 and 3 compatibility library"
LICENSE = "LGPLv2 | BSD"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/LGPL-2.0;md5=9427b8ccf5cf3df47c29110424c9641a"

SRC_URI[md5sum] = "94c114ea62aaae93489848f5bdb0bbe7"
SRC_URI[sha256sum] = "51fe0d9b3b4023db2f983eeccdfc8c9846b84db8443b9bee002c7f58f4376eff"

inherit pypi setuptools3 native
